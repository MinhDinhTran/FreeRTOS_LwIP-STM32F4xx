# Keil uVision project STM32F405_7.uvprojx, settings and files
target STM32F405_7 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F405_7 +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\CMSIS\Include;..\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\STM32F4x7_ETH_Driver\inc;..\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOSv10.3.1\include;..\FreeRTOSv10.3.1\portable\RVDS\ARM_CM4F;..\Peripheral_BSP;..\RTOS_Task;..\User;..\lwip-2.1.2\include;..\Lwip_port;..\lwip-2.1.2\include\arch
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group STM32F4x7_ETH_Driver
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group FreeRTOS
    ../FreeRTOSv10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOSv10.3.1/portable/MemMang/: heap_4.c
    ../FreeRTOSv10.3.1/portable/RVDS/ARM_CM4F/: port.c
  group Lwip_core
    ../lwip-2.1.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.1.2/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Lwip_api
    ../lwip-2.1.2/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip_netif
    ../lwip-2.1.2/netif/: ethernet.c
  group Lwip_port
    ../Lwip_port/: sys_arch.c netif_config.c netif_config.h
  group User
    ../User/: main.c stm32f4xx_it.c main.h FreeRTOSConfig.h
  group RTOS_Task
    ../RTOS_Task/: main_task.c tcp_task.c uart_task.c segment_task.c dhcp_task.c
  group Peripheral_BSP
    ../Peripheral_BSP/: stm32f4xx_eth_bsp.c stm32f4xx_uart_bsp.c stm32f4xx_heap_bsp.c stm32f4xx_fsmc_bsp.c stm32f4xx_dht22_bsp.c
